# IAR project cbm_104.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..\include; ..\ext\SmartMesh\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: cbm_104.hex
  ILINK.IlinkOutputFile: cbm_104.out
  ILINK.IlinkIcfFile: ADuCM4050_moreSRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: ADC_channel_read.c ext_flash.c main_prog.c scheduler.c shutdown.c SmartMesh_RF_cog.c SPI0_ADXL362.c SPI1_AD7685.c
  group SmartMesh
    ../ext/SmartMesh/src/: dn_endianness.c dn_hdlc.c dn_ipmt.c dn_lock.c dn_serial_mt.c dn_uart_handle.c
  group system
    ../src/system/: PinMux.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.7.0}$/CMSIS/Documentation/Core/html/: index.html
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.7.0}$/CMSIS/Core/Include/: tz_context.h
  group CMSIS-Pack/Device Drivers
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/drivers/adc/: adi_adc.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/drivers/adc/: adi_adc.h
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_adc_config.h adi_global_config.h adi_pwr_config.h adi_rtc_config.h adi_spi_config.h adi_tmr_config.h adi_uart_config.h adi_wdt_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/drivers/dma/: adi_dma.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/drivers/dma/: adi_dma.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/drivers/gpio/: adi_gpio.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/drivers/gpio/: adi_gpio.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/drivers/pwr/: adi_pwr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/drivers/pwr/: adi_pwr.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/drivers/rtc/: adi_rtc.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/drivers/rtc/: adi_rtc.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/drivers/spi/: adi_spi.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/drivers/spi/: adi_spi.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/drivers/tmr/: adi_tmr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/drivers/tmr/: adi_tmr.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/drivers/uart/: adi_uart.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/drivers/uart/: adi_uart.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/drivers/wdt/: adi_wdt.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/drivers/wdt/: adi_wdt.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Documents/html/: group___a_d_c___driver.html group___d_m_a___driver.html group___g_p_i_o___driver.html group___power___driver.html group___r_t_c___driver.html group___s_p_i___driver.html group___t_m_r___driver.html group___u_a_r_t___driver.html group___w_d_t___driver.html
  group CMSIS-Pack/Device Examples Support
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Source/: common.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/: common.h
  group CMSIS-Pack/Device Global Configuration
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_cycle_counting_config.h
  group CMSIS-Pack/Device Silicon Revision
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.4.0}$/Include/: adi_si_rev.h
  group CMSIS-Pack/Device Startup
    RTE/ADuCM4x50_DFP/AnalogDevices/: startup_ADuCM4050.s system_ADuCM4050.c system_ADuCM4050.h
